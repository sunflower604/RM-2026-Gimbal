# Keil uVision project can.uvprojx, settings and files
target can (5060960::V5.06 update 7 (build 960)::.\ARMCOMPLIER506)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: can
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../A-APPlication;../A-DEvice;../A-Driver
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c can.c dma.c i2c.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group A-APPlication
    ../A-APPlication/: Gimbal_Pitch.h Gimbal_Pitch.c Gimbal_Yaw_Small.c Gimbal_Yaw_Small.h PID.c PID.h Gimbal_Shoot.c Gimbal_Shoot.h Gimbal_Trigger.c Gimbal_Trigger.h Gimbal_Yaw_Big.c Gimbal_Yaw_Big.h Gimbal_CtoC.c Gimbal_CtoC.h ist8310driver.c ist8310driver.h ist8310driver_middleware.c ist8310driver_middleware.h Gimbal_PoseCalc.c Gimbal_PoseCalc.h
  group A-DEvice
    ../A-DEvice/: Motor.c Motor.h Remote.c Remote.h BMI088.c BMI088.h
  group A-Driver
    ../A-Driver/: bsp_can.c bsp_can.h bsp_usart.c bsp_usart.h BMI088driver.c BMI088driver.h BMI088Middleware.c BMI088Middleware.h BMI088reg.h Parameter.h
software components: CMSIS:CORE 4.3.0
